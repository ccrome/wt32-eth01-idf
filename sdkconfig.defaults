## sdkconfig.defaults
```kconfig
CONFIG_ETH_USE_SPI_ETHERNET=n
CONFIG_ETH_PHY_LAN8720=y
CONFIG_ETH_PHY_ADDR=1
CONFIG_ETH_RMII_CLK_OUT_GPIO=0
CONFIG_ETH_RMII_CLK_MODE_EXT_IN=y
```
